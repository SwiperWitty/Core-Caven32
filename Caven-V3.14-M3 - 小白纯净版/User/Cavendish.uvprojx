# Keil uVision project Cavendish.uvprojx, settings and files
target M3-Caven (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cavendish +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,Cavendish,GD
  c include: ..\User;..\CMSIS;..\Startup;..\SDK\inc;..\SDK\src;..\MCU_Cloud_LIB\API;..\MCU_Cloud_LIB\Base;..\MCU_Cloud_LIB\Mode
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: stm32f10x_it.c main.c
  group Base
    ../MCU_Cloud_LIB/Base/: ADC.c Base.c DAC.c Data_Handle.c Encoder.c IIC.c PWM.c SPI.c stmflash.c Sys_Time.c uart.c
  group Mode
    ../MCU_Cloud_LIB/Mode/: BZZ.c Control_Mode.c HC595.c key.c lcd.c mlx90614.c Mode.c Motor.c MP3.c Steering_engine.c Tracing.c Ultrasonic.c
  group API
    ../MCU_Cloud_LIB/API/: API.c Check_CRC16.c DATA.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group SDK
    ../SDK/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
