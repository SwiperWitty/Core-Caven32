# Keil uVision project Cavendish.uvprojx, settings and files
target M3-Caven (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cavendish +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,CAVEN,DEFAULT
  c include: ..\User;..\CMSIS;..\Startup;..\SDK\inc;..\Config;..\..\..\Caven-MCU_Lib\API;..\..\..\Caven-MCU_Lib\Mode;..\..\..\Caven-MCU_Lib\Base_STM32F103
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c Items.h center_app.c system_app.c caven_app.c zhiwen_app.c
  group Base
    ../../../Caven-MCU_Lib/Base_STM32F103/: Base.c Base_GPIO.c Base_ADC.c Base_Flash.c Base_IIC.c Base_SPI.c Base_Sys_Time.c Base_UART.c Base_PWM.c Base_Capture.c
  group Mode
    ../../../Caven-MCU_Lib/Mode/: Mode.c MODE_Button.c MODE_BZZ.c MODE_LCD.c MODE_LED.c MODE_MP3.c MODE_Time.c MODE_UART.c MODE_Ultrasonic.c MODE_OLED.c IC_DS18B20.c IC_HC138.c IC_HC595.c IC_MLX90614.c IC_RTC8564.c Steering_engine.c Motor_engine.c Motor_BYJ.c MODE_st7789_drive.c IC_AS608.c
  group API
    ../../../Caven-MCU_Lib/API/: API.c Caven_event_frame.c Caven_info_frame.c Caven_at_info_frame.c GX_info_frame.c Encrypt_crc.c Data_Handle.c Time_Handle.c Vofa_info.c Caven_Type.h
  group CMSIS
    ../CMSIS/: core_cm3.c
  group SDK
    ../SDK/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group Config
    ../Config/: stm32f10x_it.c system_stm32f10x.c
