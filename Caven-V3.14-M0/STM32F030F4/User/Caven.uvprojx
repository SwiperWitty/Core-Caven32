# Keil uVision project Caven.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Caven +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F030X6,USE_STDPERIPH_DRIVER,DEFAULT
  c include: ..\User;..\CMSIS;..\Startup;..\SDK\inc;..\SDK\src;..\..\..\Caven-MCU_Lib\Mode;..\..\..\Caven-MCU_Lib\API;..\..\..\Caven-MCU_Lib\Base_STM32F030;..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ./: Main.c Items.h
  group Base
    ../../../Caven-MCU_Lib/Base_STM32F030/: ADC.c Base.c Base_GPIO.c Base_IIC.c SPI.c Sys_Time.c uart.c
  group Mode
    ../../../Caven-MCU_Lib/Mode/: Control_Mode.c DS18B20.c HC138.c HC595.c mlx90614.c Mode.c MODE_Button.c MODE_BZZ.c MODE_LCD.c MODE_LED.c MODE_Motor.c MODE_Motor_BYJ.c MODE_MP3.c MODE_RTC8564.c MODE_st7789_dever.c MODE_Time.c MODE_Tracing.c MODE_UART.c MODE_Ultrasonic.c Steering_engine.c
  group API
    ../../../Caven-MCU_Lib/API/: API.c caven_at_info_frame.c Caven_event_frame.c Caven_info_frame.c DATA_Handle.c debug_log.c Encrypt_crc.c Time_Handle.c Vofa_info.c
  group SDK
    ../SDK/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CMSIS
    ../CMSIS/: arm_common_tables.h arm_math.h core_cm0.h core_cmFunc.h core_cmInstr.h core_cm0plus.h
  group Startup
    ../Startup/: startup_stm32f0xx.s
  group Config
    ../Config/: system_stm32f0xx.c
