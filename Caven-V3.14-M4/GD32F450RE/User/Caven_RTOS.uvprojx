# Keil uVision project Caven_RTOS.uvprojx, settings and files
target default (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450,DEFAULT
  c include: ..\CMSIS;..\Config;..\SDK\inc;..\Startup;..\User;..\..\..\Caven-MCU_Lib\Base_GD32F450;..\..\..\Caven-MCU_Lib\Mode;..\..\..\Caven-MCU_Lib\API
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: base_adc.c base_SPI.c main.c main-ADC.c main-delay.c main-Flash.c main-SPI.c base_Flash.c cpuspec.c macadc.c rand.c Items.h
  group Base
    ../../../Caven-MCU_Lib/Base_GD32F450/: Base.c Base_GPIO.c Base_Sys_Time.c Base_UART.c Base_IIC.c Base_PWM.c
  group Mode
    ../../../Caven-MCU_Lib/Mode/: IC_DS18B20.c IC_HC138.c IC_HC595.c IC_MLX90614.c IC_RTC8564.c Mode.c MODE_Button.c MODE_BZZ.c MODE_LCD.c MODE_LED.c MODE_MP3.c MODE_OLED.c MODE_st7789_dever.c MODE_Time.c MODE_Tracing.c MODE_UART.c MODE_Ultrasonic.c Motor_BYJ.c Motor_engine.c Steering_engine.c
  group API
    ../../../Caven-MCU_Lib/API/: API.c caven_at_info_frame.c Caven_event_frame.c Caven_info_frame.c cJSON.c DATA_Handle.c Encrypt_crc.c Time_Handle.c Vofa_info.c Caven_Type.h
  group Config
    ../Config/: gd32f4xx_it.c system_gd32f4xx.c
  group CMSIS
    ../CMSIS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group Peripherals
    ../SDK/src/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Startup/: startup_gd32f450_470.s
