# Keil uVision project Caven.uvprojx, settings and files
target Default (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F415RCT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.7
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Cavendish +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,CAVEN,STB_SPRINTF_IMPLEMENTATION,DEFAULT
  c include: ..\User;..\CMSIS;..\Config;..\SDK\inc;..\Startup\mdk;..\..\..\Caven-MCU_Lib\API;..\..\..\Caven-MCU_Lib\GUI;..\..\..\Caven-MCU_Lib\Mode;..\..\..\Caven-MCU_Lib\Base_AT32F415;..\..\..\Caven-MCU_Lib\Base_AT32F415\usb_drivers\inc;..\..\..\Caven-MCU_Lib\Base_AT32F415\composite_HID;..\..\..\Caven-MCU_Lib\API\STB;..\..\..\Caven-MCU_Lib\Base_AT32F415\usbd_class\cdc;..\..\..\Caven-MCU_Lib\Base_AT32F415\usbd_class\custom_hid
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./: center_app.c Main.c Items.h caven_app.c gx_app.c system_app.c
  group Base
    ../../../Caven-MCU_Lib/Base_AT32F415/: Base.c Base_ADC.c Base_Flash.c Base_IIC.c Base_GPIO.c Base_PWM.c Base_SPI.c Base_Sys_Time.c Base_UART.c Base_Capture.c Base_USB.c
    ../../../Caven-MCU_Lib/Base_AT32F415/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
    ../../../Caven-MCU_Lib/Base_AT32F415/composite_HID/: cdc_keyboard_class.c cdc_keyboard_desc.c
    ../../../Caven-MCU_Lib/Base_AT32F415/usbd_class/cdc/: cdc_class.c cdc_desc.c
  group Mode
    ../../../Caven-MCU_Lib/Mode/: IC_DS18B20.c IC_HC138.c IC_HC595.c IC_MLX90614.c IC_RTC8564.c Mode.c MODE_Button.c MODE_BZZ.c MODE_LCD.c MODE_LED.c MODE_MP3.c MODE_OLED.c MODE_Time.c MODE_UART.c MODE_Ultrasonic.c Motor_BYJ.c Motor_engine.c Steering_engine.c MODE_st7789_drive.c
  group API
    ../../../Caven-MCU_Lib/API/: API.c caven_at_info_frame.c Caven_event_frame.c Caven_info_frame.c DATA_Handle.c Encrypt_crc.c Time_Handle.c Vofa_info.c Caven_Type.h GX_info_frame.c
  group GUI
    ../../../Caven-MCU_Lib/GUI/: caven_gui.c
  group Config
    ../Config/: at32f415_clock.c at32f415_int.c system_at32f415.c at32f415_conf.h
  group Startup
    ../Startup/mdk/: startup_at32f415.s
  group CMSIS
    ../CMSIS/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h
  group SDK
    ../SDK/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
