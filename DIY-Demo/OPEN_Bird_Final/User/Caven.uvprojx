# Keil uVision project Caven.uvprojx, settings and files
target Default (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F415RCT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Cavendish +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,CAVEN,DEFAULT,INS_HSCLK
  c include: ..\User;..\CMSIS;..\Config;..\SDK\inc;..\Startup\mdk;..\..\..\Caven-MCU_Lib\API;..\..\..\Caven-MCU_Lib\Mode;..\..\..\Caven-MCU_Lib\Base_AT32F415;..\..\..\Caven-MCU_Lib\Base_AT32F415\usb_drivers\inc;..\..\..\Caven-MCU_Lib\Base_AT32F415\composite_HID;..\..\..\Caven-MCU_Lib\GUI;..\bird_gui\lvgl;..\bird_gui\ui;..\bird_gui
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./: Main.c Items.h
  group Base
    ../../../Caven-MCU_Lib/Base_AT32F415/: Base.c Base_ADC.c Base_Flash.c Base_GPIO.c Base_IIC.c Base_PWM.c Base_SPI.c Base_Sys_Time.c Base_UART.c Base_USB.c
  group Mode
    ../../../Caven-MCU_Lib/Mode/: Mode.c Control_Mode.c DS18B20.c HC138.c HC595.c mlx90614.c MODE_BZZ.c MODE_LED.c MODE_Motor.c MODE_Motor_BYJ.c MODE_MP3.c Mode_RTC8564.c MODE_Time.c MODE_Tracing.c MODE_UART.c MODE_Ultrasonic.c Steering_engine.c MODE_Button.c MODE_LCD.c MODE_st7789_dever.c
  group API
    ../../../Caven-MCU_Lib/API/: API.c Caven_event_frame.c Caven_info_frame.c DATA_Handle.c Time_Handle.c Vofa_info.c Encrypt_crc.c
  group GUI
    ../../../Caven-MCU_Lib/GUI/: caven_gui.c
  group Config
    ../Config/: at32f415_clock.c at32f415_int.c system_at32f415.c at32f415_conf.h
  group Startup
    ../Startup/mdk/: startup_at32f415.s
  group CMSIS
    ../CMSIS/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h
  group SDK
    ../SDK/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group lvgl_src
    ../bird_gui/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../bird_gui/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../bird_gui/lvgl/src/extra/: lv_extra.c
    ../bird_gui/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../bird_gui/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../bird_gui/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../bird_gui/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../bird_gui/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../bird_gui/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../bird_gui/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../bird_gui/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../bird_gui/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../bird_gui/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../bird_gui/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../bird_gui/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../bird_gui/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../bird_gui/lvgl/src/extra/widgets/win/: lv_win.c
    ../bird_gui/lvgl/src/extra/widgets/span/: lv_span.c
    ../bird_gui/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../bird_gui/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../bird_gui/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../bird_gui/lvgl/src/extra/widgets/list/: lv_list.c
    ../bird_gui/lvgl/src/extra/widgets/led/: lv_led.c
    ../bird_gui/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../bird_gui/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../bird_gui/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../bird_gui/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../bird_gui/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../bird_gui/lvgl/src/extra/others/msg/: lv_msg.c
    ../bird_gui/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../bird_gui/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../bird_gui/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../bird_gui/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../bird_gui/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../bird_gui/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../bird_gui/lvgl/src/extra/themes/default/: lv_theme_default.c
  group lvlg_gui
    ../bird_gui/ui/: ui.c ui_helpers.c
    ../bird_gui/ui/components/: ui_comp_hook.c
    ../bird_gui/ui/screens/: ui_cone.c
