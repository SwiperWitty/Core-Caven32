# Keil uVision project Caven.uvprojx, settings and files
target Default (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F415RCT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Cavendish +hex
  AfterMake: D:\MDK\ARM\ARMCLANG\bin\fromelf.exe --bin --output ../OBJ/Cavendish.bin ../OBJ/Cavendish.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,CAVEN,DEFAULT,Ins_HSCLK
  c include: ..\User;..\CMSIS;..\Config;..\SDK\inc;..\Startup\mdk;..\..\..\Caven-MCU_Lib\API;..\..\..\Caven-MCU_Lib\Mode;..\..\..\Caven-MCU_Lib\Base_AT32F415;..\..\..\Caven-MCU_Lib\Base_AT32F415\usb_drivers\inc;..\..\..\Caven-MCU_Lib\Base_AT32F415\composite_HID
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./: Main.c Items.h power_app.c
  group Base
    ../../../Caven-MCU_Lib/Base_AT32F415/: Base.c Base_ADC.c Base_Exist_GPIO.c Base_Flash.c Base_IIC.c Base_PWM.c Base_SPI.c Base_Sys_Time.c Base_UART.c
    ../../../Caven-MCU_Lib/Base_AT32F415/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
    ../../../Caven-MCU_Lib/Base_AT32F415/composite_HID/: cdc_keyboard_class.c cdc_keyboard_desc.c usb_user.c
  group Mode
    ../../../Caven-MCU_Lib/Mode/: Mode.c MODE_LCD.c Control_Mode.c DS18B20.c HC138.c HC595.c mlx90614.c MODE_BZZ.c MODE_LED.c MODE_Motor.c MODE_Motor_BYJ.c MODE_MP3.c Mode_RTC8564.c MODE_Time.c MODE_Tracing.c MODE_UART.c MODE_Ultrasonic.c Steering_engine.c MODE_Button.c
  group API
    ../../../Caven-MCU_Lib/API/: API.c Caven_event_frame.c Caven_info_frame.c Check_CRC.c DATA_Handle.c Keyboard.c libcollections.c Time_Handle.c Vofa_info.c
  group Config
    ../Config/: at32f415_clock.c at32f415_int.c system_at32f415.c at32f415_conf.h
  group Startup
    ../Startup/mdk/: startup_at32f415.s
  group CMSIS
    ../CMSIS/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h
  group SDK
    ../SDK/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
