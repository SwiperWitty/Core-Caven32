# Keil uVision project Cavend.uvprojx, settings and files
target Cavend (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L110C6PA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Cavend +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: DEFAULT,LOW_POW
  c include: ..\CMSIS;..\Config;..\SDK\inc;..\Startup;..\User;.\driver
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group User
    ./: Main.c Items.h
  group Driver
    ./driver/: Base_ADC.c Base_UART.c Base_Sys_Time.c Base_GPIO.c
  group Config
    ../Config/: system_hc32l110.c interrupts_hc32l110.c
  group SDK
    ../SDK/src/: adc.c adt.c bt.c clk.c crc.c ddl.c flash.c gpio.c i2c.c lpm.c lpt.c lpuart.c lvd.c pca.c reset.c rtc.c spi.c trim.c uart.c vc.c wdt.c
  group Startup
    ../Startup/: startup_hc32l110.s
software components: CMSIS:CORE 5.4.0
