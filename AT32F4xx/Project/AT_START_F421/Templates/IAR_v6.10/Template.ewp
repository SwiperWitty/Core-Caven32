# IAR project Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F421C8T7 ArteryTek AT32F421C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: AT32F421C8T7; USE_STDPERIPH_DRIVER; AT_START_F421_V1_0
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\CM4\CoreSupport; ..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport; ..; ..\..\..\AT32_Board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ArteryTek\AT32F415xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group AT32Periph
    ../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c misc.c
  group BSP
    ../../../AT32_Board/: at32_board.c
  group CMSIS
    ../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f421c8t7.s
    ../: system_at32f4xx.c
  group README
    ../: readme.txt
  group USER
    ../: at32f4xx_it.c main.c
