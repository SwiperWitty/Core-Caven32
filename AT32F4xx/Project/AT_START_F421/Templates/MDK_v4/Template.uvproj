# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: AT32F421C8T7 ArteryTek
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: Template +hex
  c flags: Optim=1
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER, AT_START_F421_V1_0
  c include: ..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\Templates;..\..\..\AT32_Board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ../: main.c at32f4xx_it.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f421c8t7.s
  group AT32Periph
    ../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_ertc.c at32f4xx_comp.c at32f4xx_syscfg.c misc.c
  group README
    ../: readme.txt
  group BSP
    ../../../AT32_Board/: at32_board.c
