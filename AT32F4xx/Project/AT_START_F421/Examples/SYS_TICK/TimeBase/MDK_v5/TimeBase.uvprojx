# Keil uVision project TimeBase.uvprojx, settings and files
target TimeBase (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F421C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: TimeBase
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1_0
  c include: ..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\TimeBase;..\..\..\..\..\AT32_Board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ../: main.c at32f4xx_it.c
  group BSP
    ../../../../../AT32_Board/: at32_board.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f421c8t7.s
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio_ex.c at32f4xx_rcc.c misc.c at32f4xx_usart.c
  group README
    ../: readme.txt
