# Keil uVision project ADC.uvprojx, settings and files
target ADC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F421C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: ADC
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1_0
  c include: ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\ExtLinesTrigger;..\..\..\..\..\AT32_Board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ../: main.c at32f4xx_it.c
  group BSP
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_usart.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f421c8t7.s
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: misc.c at32f4xx_adc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_gpio_ex.c at32f4xx_rcc.c at32f4xx_syscfg.c
  group README
    ../: readme.txt
