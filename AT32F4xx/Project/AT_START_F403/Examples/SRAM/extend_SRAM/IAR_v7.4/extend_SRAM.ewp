# IAR project extend_SRAM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403ZG ArteryTek AT32F403ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F403Zx_XL; USE_STDPERIPH_DRIVER; AT_START_F403_V1_2; EXTEND_SRAM_224K
  ICCARM.CCIncludePath2: ..\EXTEND_SRAM; ..; ..\..\..\..\..\AT32_Board; ..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport; ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: extend_SRAM.hex
  ILINK.IlinkOutputFile: extend_SRAM.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_usart.c misc.c
  group BSP
    ../../../../../AT32_Board/: at32_board.c
  group CMSIS
    ../: iar_startup_at32f403zx_xl_ext_ram.s system_at32f4xx.c
  group EXTEND_SRAM
    ../EXTEND_SRAM/: extend_SRAM.c
  group User
    ../: at32f4xx_it.c main.c
