# Keil uVision project RTOS.uvprojx, settings and files
target RTOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F403ZG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403Zx_XL,USE_STDPERIPH_DRIVER,AT_START_F403_V1_2
  c include: ..\..\..\..\..\..\..\Middlewares\FreeRTOS\Source\include;..\..\..\..\..\..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\bsp;..\bsp\inc;..\..\Project;..\..\..\..\..\..\AT32_Board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group User
    ../: main.c FreeRTOSConfig.h TimerForRunTimeState.c at32f4xx_assert.c at32f4xx_it.c
  group BSP
    ../bsp/: bsp.c
    ../bsp/src/: bsp_uart_fifo.c bsp_led.c bsp_key.c bsp_tim_pwm.c bsp_timer.c
    ../../../../../../AT32_Board/: at32_board.c
  group MDK-ARM
    ../../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403zx_xl.s
  group StdPeriph_Driver
    ../../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_exti.c at32f4xx_gpio.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_rcc.c misc.c
  group CMSIS
    ../: system_at32f4xx.c
  group FreeRTOS/Source
    ../../../../../../../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c readme.txt stream_buffer.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../../../../../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../../../../../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Doc
    ../: readme.txt
