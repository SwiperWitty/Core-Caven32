# Keil uVision project HOST_MSC.uvprojx, settings and files
target HOST_MSC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT32F415RCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.4
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: HOST_MSC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER, AT_START_F415_V1_0
  c include: ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\..\..\AT32_Board;..\inc;..\..\..\..\..\..\Middlewares\AT32_USB_OTG_Library\USB_OTG_Driver\inc;..\..\..\..\..\..\Middlewares\AT32_USB_OTG_Library\USB_Host_Library\Class\MSC\inc;..\..\..\..\..\..\Middlewares\AT32_USB_OTG_Library\USB_Host_Library\Core\inc;..\..\..\..\..\..\Middlewares\AT32_USB_OTG_Library\fat_fs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../src/: at32f4xx_it.c main.c usb_bsp.c usbh_usr.c
  group CMSIS
    ../src/: system_at32f4xx.c
    ../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f415rct7.s
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_usart.c misc.c at32f4xx_exti.c at32f4xx_tim.c
  group BSP
    ../../../../../AT32_Board/: at32_board.c
  group OTG_USB_Host_Library
    ../../../../../../Middlewares/AT32_USB_OTG_Library/USB_Host_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group OTG_USB_Driver
    ../../../../../../Middlewares/AT32_USB_OTG_Library/USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_Host_Class
    ../../../../../../Middlewares/AT32_USB_OTG_Library/USB_Host_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group FAT_FS
    ../../../../../../Middlewares/AT32_USB_OTG_Library/fat_fs/src/: ff.c
  group README
    ../: readme.txt
