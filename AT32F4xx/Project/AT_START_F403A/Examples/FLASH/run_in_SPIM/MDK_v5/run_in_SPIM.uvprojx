# Keil uVision project run_in_SPIM.uvprojx, settings and files
target RUN_IN_SPIM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: run_in_SPIM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1_0
  c include: ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\SPIM;..\..\run_in_SPIM;..\..\..\..\..\AT32_Board
  library: MicroLIB
  memory RVCT1: ROM 0x8500000 size 0x700000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group SPIM
    ../SPIM/: run_in_SPIM.c LED_run.c
  group USER
    ../: main.c at32f4xx_it.c
  group BSP
    ../../../../../AT32_Board/: at32_board.c
  group CMSIS
    ../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403avgt7.s
    ../: system_at32f4xx.c
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_usart.c misc.c
  group README
    ../: readme.txt
