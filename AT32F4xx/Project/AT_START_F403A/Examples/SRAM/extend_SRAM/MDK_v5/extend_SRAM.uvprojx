# Keil uVision project extend_SRAM.uvprojx, settings and files
target set_SRAM_96K (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: set_SRAM_96K +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,EXTEND_SRAM_96K,AT_START_F403A_V1_0
  c include: ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\EXTEND_SRAM;..\..\extend_SRAM;..\..\..\..\..\AT32_Board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group EXTEND_SRAM
    ../EXTEND_SRAM/: extend_SRAM.c
  group USER
    ../: main.c at32f4xx_it.c
  group BSP
    ../../../../../AT32_Board/: at32_board.c
  group CMSIS
    ../: system_at32f4xx.c startup_at32f403avgt7_ext_ram.s
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_usart.c misc.c
  group README
    ../: readme.txt
target set_SRAM_224K (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: as above
  output: set_SRAM_224K +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,EXTEND_SRAM_224K,AT_START_F403A_V1_0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
